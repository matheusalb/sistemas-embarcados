# Keil uVision project Experimento6.uvproj, settings and files
target Target 1 (MCS-51)
  device: SAB 80C517A Infineon
  cpu: IRAM(0-0xFF) CLOCK(18000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: Experimento6
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Experimento6.c
